File: Hardware/IMU_Circuit/IMU_Circuit.sch (KiCad schematic (older format))
At the start: 8 parts

Commit message: Shematic merger and stuff
Other:
- moved on the sheet: C?, U?
