# Repository jsjolund/sailoraid (continued)

## KiCad design Hardware/CPU_Board/CPU_Board.kicad_pcb

Parts:
C1: 1u; C_0805_HandSoldering
C2, C3: 18p; C_0805_HandSoldering
C4, C5, C9: 4.7u; CP_Elec_4x5.3
C6, C8, C10, C11, C12, C13, C14, C15, C16, C18, C20, C22, C27, C30: 100n; C_0805_HandSoldering
C7, C17, C19: 10u; CP_Elec_5x5.3
C21: 1uF; C_0805_HandSoldering
C23: 220nF; C_0805_HandSoldering
C24: 10uF; CP_Elec_5x5.3
C25, C26, C28, C29: 100nF; C_0805_HandSoldering
D1: D_Zener; D_SOD-323
D2: D_Photo; PhotoDiode_SFH205
L1: L_Core_Ferrite_500mA; R_1206_HandSoldering
L2, L3: 330uH; INDUCTOR_V
P1: CONN_01X02; AK300-2
P2: USB_B
P3: CONN_01X04; Pin_Header_Straight_1x04_Pitch2.54mm
P4, P9: CONN_01X06; Pin_Header_Straight_1x06_Pitch2.54mm
P5, P6, P7, P8: CONN_01X02; Pin_Header_Straight_1x02_Pitch2.54mm
P10, P12, P14: CONN_01X03; Pin_Header_Straight_1x03_Pitch2.54mm
P11, P13: CONN_01X01; Pin_Header_Straight_1x01_Pitch2.54mm
P15, P16, P17, P18, P19, P20: CONN_01X01; MountingHole_2.2mm_M2_DIN965_Pad
Q1: Q_PMOS_GSD; SOT-23_Handsoldering
Q2, Q3: Q_PNP_BCE; SOT-23_Handsoldering
Q4: N-Channel; SOT-23_Handsoldering
Q5: P-Channel; SOT-23_Handsoldering
R1, R2, R7, R8, R11, R13, R16, R18: 10k; R_0805_HandSoldering
R3: 2.7k; R_0805_HandSoldering
R4, R5: 6.8k; R_0805_HandSoldering
R6, R9: 10K; R_0805_HandSoldering
R10: 47K; R_0805_HandSoldering
R12: 5360; R_0805_HandSoldering
R14: 0C; R_Axial_DIN0204_L3.6mm_D1.6mm_P1.90mm_Vertical
R15, R17, R19, R20: 1k; R_0805_HandSoldering
R21: 0R; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
U1: STM32F411RETx; LQFP-64_10x10mm_Pitch0.5mm
U2: FT232RL; SSOP-28_5.3x10.2mm_Pitch0.65mm
U3: LM1117ADJ; SOT-223
U4: SPBTLE-RF; ST_SPBTLE
U5: A2235-H; A2235-H_Handsolder
U6: LSM303AGR; LGA-12_2x2mm_Pitch0.5mm
U7: LSM6DSL; LGA-14
U8: MCDTS2-4N; SW_SPST_PTS645
U9: INA128; SO-8_5.3x6.2mm_Pitch1.27mm
Y1: 8MHz; Crystal_SMD_HC49-SD

Connections:
+3.3VADC: C18.1, L3.1, P14.3
+3V3: C1.2, C4.1, C9.1, C11.2, C12.2, C14.2, C16.2, C19.1, C20.1, C21.1, C22.1, C24.1, C25.1, C26.1, C28.1, C29.1, C30.2, D2.1, L3.2, P4.1, P10.3, Q4.3 (D), R1.2, R6.2, R8.2, R9.2, R11.1, R13.1, R18.2, R20.1, U1.1 (VBAT), U1.13 (VREF+), U1.19 (VDD), U1.32 (VDD), U1.48 (VDD), U1.64 (VDD), U2.4 (VCCIO), U3.2 (Vout), U3.4 (Vout2), U4.5 (VIN), U5.3 (VCC_3V3), U6.2, U6.3, U6.9, U6.10, U7.1 (SA0), U7.2 (SDx), U7.3 (SCx), U7.5 (VDDIO), U7.8 (VDD), U7.12 (CS)
+5V: P1.2, P10.1, Q1.3 (D)
+5VA: C15.1, L2.1, P3.4, P14.1, U9.7 (V+)
/303C_DRDY: P12.3, U1.26 (ADC1_IN8/I2S5_CK/SPI5_SCK/TIM1_CH2N/TIM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), U6.11
/303C_I_MAG: P12.1, U1.21 (ADC1_IN5/I2S1_CK/SPI1_SCK/TIM2_CH1/TIM2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), U6.7
/303C_I_XL: P12.2, U1.20 (ADC1_IN4/I2S1_WS/I2S3_WS/SPI1_NSS/SPI3_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), U6.12
/BT_5_PA0: P9.6, R10.2, U1.14 (ADC1_IN0/SYS_WKUP/TIM2_CH1/TIM2_ETR/TIM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), U4.4 (SPI_IRQ)
/BT_7_PB3: P9.3, U1.55 (I2C2_SDA/I2S1_CK/I2S3_CK/SPI1_SCK/SPI3_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), U4.7 (SPI_CLK)
/BT_8_PA6: P9.2, U1.22 (ADC1_IN6/I2S2_MCK/SDIO_CMD/SPI1_MISO/TI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), U4.8 (SPI_MISO)
/BT_9_PA7: P9.4, U1.23 (ADC1_IN7/I2S1_SD/SPI1_MOSI/TIM1_CH1N/TI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), U4.9 (SPI_MOSI)
/BT_10_PA1: P9.5, R6.1, U1.15 (ADC1_IN1/I2S4_SD/SPI4_MOSI/TIM2_CH2/TIM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), U4.10 (SPI_CS)
/BT_11_PA8: P9.1, R9.1, U1.41 (I2C3_SCL/RCC_MCO_1/SDIO_D1/TIM1_CH1/USA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), U4.11 (~BT_RESET~)
/GPS_RX: P7.1, R13.2, U1.42 (I2C3_SMBA/SDIO_D2/TIM1_CH2/USART1_TX/US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), U5.22 (RX0)
/GPS_TOGGLE: P11.1, R14.2, R17.2, U1.44 (ADC1_EXTI11/SPI4_MISO/TIM1_CH4/USART1_C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)
/GPS_TX: P7.2, R11.2, U1.43 (I2S5_SD/SPI5_MOSI/TIM1_CH3/USART1_RX/US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), U5.21 (TX0)
/IMU_I2C_CL: P5.2, U1.61 (I2C1_SCL/I2C3_SDA/I2S5_SD/SDIO_D4/SPI5_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), U6.1, U7.13 (SCL)
/IMU_I2C_DA: P5.1, U1.62 (I2C1_SDA/I2C2_SDA/I2S2_WS/SDIO_D5/SPI2_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), U6.4, U7.14 (SDA)
/LSM6DSL_INT1: P8.2, U1.56 (I2C3_SDA/I2S3_ext_SD/SDIO_D0/SPI1_MISO/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), U7.4 (INT1)
/LSM6DSL_INT2: P8.1, U1.57 (I2C1_SMBA/I2S1_SD/I2S3_SD/SDIO_D3/SPI1_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), U7.9 (INT2)
/Load_cell_amp: P13.1, U1.24 (PC4/ADC1_IN14), U9.6
/NRST: P4.5, R1.1, U1.7 (NRST)
/PC13: C27.1, R18.1, U1.2 (PC13/ANTI_TAMP/RTC_AF1), U8.1
/SWCLK: P4.2, U1.49 (SYS_JTCK-SWCLK/PA14)
/SWDIO: P4.4, U1.46 (SYS_JTMS-SWDIO/PA13)
/USB_USART_RX: P6.2, U1.17 (ADC1_IN3/I2S2_MCK/TIM2_CH4/TIM5_CH4/TIM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), U2.1 (TXD)
/USB_USART_TX: P6.1, U1.16 (ADC1_IN2/I2S_CKIN/TIM2_CH3/TIM5_CH3/TIM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), U2.5 (RXD)
GND: C1.1, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.1, C12.1, C13.2, C14.1, C16.1, C17.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.1, D1.2 (A), D2.2, P1.1, P2.4 (GND), P2.5 (shield), P4.3, P10.2, Q1.1 (G), Q5.3 (D), R2.2, R5.1, R10.1, R15.1, R19.1, R21.1, U1.12 (VSSA), U1.18 (VSS), U1.31 (VSS), U1.47 (VSS), U1.63 (VSS), U2.7 (GND), U2.18 (GND), U2.21 (GND), U2.25 (AGND), U2.26 (TEST), U3.1 (ADJ), U4.6 (GND), U5.6 (GND), U5.9 (GND), U5.20 (ExtInt/GPIO8), U5.23 (GND_PAD1), U5.24 (GND_PAD2), U5.25 (GND_PAD3), U5.26 (GND_PAD4), U5.27 (GND_PAD5), U5.28 (GND_PAD6), U5.29 (GND_PAD7), U5.30 (GND_PAD8), U6.6, U6.8, U7.6 (GND), U7.7 (GND)
GNDA: C15.2, C18.2, P3.1, P14.2, R21.2, U1.25 (PC5/ADC1_IN15), U9.4 (V-), U9.5 (Ref)
unnamed: C2.1, U1.5 (PH0/RCC_OSC_IN), Y1.1
unnamed: C3.1, U1.6 (PH1/RCC_OSC_OUT), Y1.2
unnamed: C5.1, U1.30 (VCAP1)
unnamed: C6.1, C7.1, C8.1, L1.2, U2.20 (VCC)
unnamed: C10.1, C13.1, C17.1, L2.2, Q3.2 (C), U3.3 (Vin)
unnamed: C23.1, U6.5
unnamed: D1.1 (K), R3.2, R4.2
unnamed: L1.1, P2.1 (VBUS)
unnamed: P2.2 (D-), U2.16 (USBDM)
unnamed: P2.3 (D+), U2.15 (USBDP)
unnamed: P3.2, U9.2 (-)
unnamed: P3.3, U9.3 (+)
unnamed: Q1.2 (S), Q2.3 (E), Q3.3 (E), R3.1
unnamed: Q2.1 (B), R4.1
unnamed: Q2.2 (C), Q3.1 (B), R5.2
unnamed: Q4.1 (G), Q5.1 (G), R17.1
unnamed: Q4.2 (S), Q5.2 (S), R14.1, R16.2, U5.19 (ON_OFF)
unnamed: R2.1, U1.60 (BOOT0)
unnamed: R7.1, U5.5 (Vout)
unnamed: R7.2, U5.7 (GPIO6/SPI_CLK)
unnamed: R8.1, U5.1 (nRST)
unnamed: R12.1, U9.1 (Rg)
unnamed: R12.2, U9.8 (Rg)
unnamed: R15.2, U8.2
unnamed: R16.1, R19.2, R20.2

Notes on the sheet:
NOTE: RX to TX, TX to RX
Mounting Holes
USB USART Connection for Programming Using FT232RL
Measurement Nodes MCU
Main chip, STM32F411RET, and lables only. Sensor architectures in their own boxes, well documented.
Required circuitry
Autowakeup: 4 to 16
Antenna? To where?
7op for I2C , 7cl for UART;
8op for UART, 8cl for I2C;
Timekeeping? 1PPS signal
For I2C use
GPS: A2235-H schematic Datasheet: http://www.mouser.com/catalog/specsheets/EVA2235-H.pdf
Pullups
GPS
Pull to Reference
High-speed digital switching logic
3V3/2 = 1.65V
Amplifier for load cell, connects to TH and Analog
LSM303AGR VDD Decoup. Cap.
LSM303AGR VDD_IO Decoup. Cap.
LSM6DSL VDD Decoup. Cap.
LSM6DSL VDD_IO Decoup. Cap.
I2C1 och I2C2 är ihopkopplade som standard på IKS01A2. Vi får välja vilken vi ska använda och så kan vi strunta i den andra.
IMU circuitry
MCU Connects?
IMU
Bluetooth connection module
Power input from battery dock board
Measurement Nodes USB
Measurement Nodes GPS
Toggle signal GPS
Measurement Nodes IMU 1: (Magneto & Acc.) 2: (Gyro & Acc.)
IMU 1 interrupt pins
IMU 2 interrupt pins
Reset SPI_MISO SPI_MOSI SPI_CLK SPI_CS SPI_IRQ
Measurement Nodes BT-LE
Measurement Nodes Digital Power Pins
Measurement Nodes Analog Power Pins
Measurement Nodes Load Cell

Board: 2 copper layers, 272.7 x 170.7 mm, 91 parts (0 on the bottom side), 54 nets.

## Code that names these connections

File sailoraid.ioc (part):

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Mcu.Name=STM32F411R(C-E)Tx
Mcu.Package=LQFP64
Mcu.UserName=STM32F411RETx
PA0-WKUP.GPIOParameters=GPIO_Label
PA0-WKUP.GPIO_Label=BNRG_SPI_IRQ
PA0-WKUP.Signal=GPXTI0
PA1.GPIOParameters=GPIO_Speed,PinState,GPIO_Label
PA1.GPIO_Label=BNRG_SPI_CS
PA1.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PA1.PinState=GPIO_PIN_RESET
PA1.Signal=GPIO_Output
PA10.GPIOParameters=GPIO_Label
PA10.GPIO_Label=GPS_USART_RX
PA10.Mode=Asynchronous
PA10.Signal=USART1_RX
PA11.GPIOParameters=GPIO_PuPd,GPIO_Label
PA11.GPIO_Label=GPS_ON_OFF
PA11.GPIO_PuPd=GPIO_PULLUP
PA11.Signal=GPIO_Output
PA13.GPIOParameters=GPIO_Label
PA13.GPIO_Label=TMS
PA13.Mode=Serial_Wire
PA13.Signal=SYS_JTMS-SWDIO
PA14.GPIOParameters=GPIO_Label
PA14.GPIO_Label=TCK
PA14.Mode=Serial_Wire
PA14.Signal=SYS_JTCK-SWCLK
PA2.GPIOParameters=GPIO_Label
PA2.GPIO_Label=USB_USART_TX
PA2.Mode=Asynchronous
PA2.Signal=USART2_TX
PA3.GPIOParameters=GPIO_Label
PA3.GPIO_Label=USB_USART_RX
PA3.Mode=Asynchronous
PA3.Signal=USART2_RX
PA5.GPIOParameters=GPIO_Label
PA5.GPIO_Label=LED2
PA5.Signal=GPIO_Output
PA6.GPIOParameters=GPIO_Label
PA6.GPIO_Label=BNRG_SPI_MISO
PA6.Mode=Full_Duplex_Master
PA6.Signal=SPI1_MISO
PA7.GPIOParameters=GPIO_Label
PA7.GPIO_Label=BNRG_SPI_MOSI
PA7.Mode=Full_Duplex_Master
PA7.Signal=SPI1_MOSI
PA8.GPIOParameters=GPIO_Speed,GPIO_Label
PA8.GPIO_Label=BNRG_SPI_RESET
PA8.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PA8.Signal=GPIO_Output
PA9.GPIOParameters=GPIO_Label
PA9.GPIO_Label=GPS_USART_TX
PA9.Mode=Asynchronous
PA9.Signal=USART1_TX
PB10.GPIOParameters=GPIO_Label
PB10.GPIO_Label=LPS22H_INT1_O
PB10.Signal=GPXTI10
PB3.GPIOParameters=GPIO_Label
PB3.GPIO_Label=BNRG_SPI_SCLK
PB3.Mode=Full_Duplex_Master
PB3.Signal=SPI1_SCK
PB4.GPIOParameters=GPIO_Label
PB4.GPIO_Label=LSM6DSL_INT1_O
PB4.Signal=GPXTI4
PB5.GPIOParameters=GPIO_Label
PB5.GPIO_Label=LSM6DSL_INT2_O
PB5.Signal=GPXTI5
PB8.GPIOParameters=GPIO_Label
PB8.GPIO_Label=I2C_SCL
PB8.Mode=I2C
PB8.Signal=I2C1_SCL
PB9.GPIOParameters=GPIO_Label
PB9.GPIO_Label=I2C_SDA
PB9.Mode=I2C
PB9.Signal=I2C1_SDA
PC1.GPIOParameters=GPIO_PuPd,GPIO_Label,GPIO_ModeDefaultOutputPP
PC1.GPIO_Label=GPS_NRST
PC1.GPIO_ModeDefaultOutputPP=GPIO_MODE_OUTPUT_PP
PC1.GPIO_PuPd=GPIO_PULLUP
PC1.Signal=GPIO_Output
PC13-ANTI_TAMP.GPIOParameters=GPIO_Label,GPIO_ModeDefaultEXTI
PC13-ANTI_TAMP.GPIO_Label=USER_BUTTON
PC13-ANTI_TAMP.GPIO_ModeDefaultEXTI=GPIO_MODE_IT_FALLING
PC13-ANTI_TAMP.Signal=GPXTI13
PC14-OSC32_IN.Mode=LSE-External-Oscillator
PC14-OSC32_IN.Signal=RCC_OSC32_IN
PC15-OSC32_OUT.Mode=LSE-External-Oscillator
PC15-OSC32_OUT.Signal=RCC_OSC32_OUT
PC4.GPIOParameters=GPIO_Label
PC4.GPIO_Label=LOAD_CELL_0_ADC
PC4.Signal=ADCx_IN14
PC5.GPIOParameters=GPIO_Label
PC5.GPIO_Label=LOAD_CELL_1_ADC
PC5.Signal=ADCx_IN15
PC9.GPIOParameters=PinState,GPIO_Label
PC9.GPIO_Label=RANGE_SHDN
PC9.PinState=GPIO_PIN_SET
PC9.Signal=GPIO_Output
PH0\ -\ OSC_IN.Mode=HSE-External-Oscillator
PH0\ -\ OSC_IN.Signal=RCC_OSC_IN
PH1\ -\ OSC_OUT.Mode=HSE-External-Oscillator
PH1\ -\ OSC_OUT.Signal=RCC_OSC_OUT
RCC.HSE_VALUE=8000000
RCC.SYSCLKFreq_VALUE=100000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=NUCLEO-F411RE
boardIOC=true

## Commit log (part)

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2017-08-31 Added LaTeX report template
2017-08-31 Test
2017-08-31 Test3
2017-08-31 Added generated stm32cubemx files
2017-09-02 Hardware project added
    Added Hardware:
    * Libraries
    o Customs
    - Officials
    * CPU_Board (Main board)
    - Project file
2017-09-05 Add folder
2017-09-05 Android project
2017-09-05 Bluetooth lib test
2017-09-05 allow .lib
2017-09-05 GPS, libraries and datasheet list
    GPS: A2235-h added to schematic in UART settings. ON-OFF not finished!
    Libraries:
    - DCDCconv, ft232rl, lm1117, max3485e, stm32 (from kicad std-lib),
    stm32f100, stm32f4.
    * CUSTOM
    - A2235-H
2017-09-06 GPS proper shut-ON/OFF logic
    Possible solution to support startup/shutdown sequence (GPIO - PA11).
    Might take away filter and add a second logical gate for faster (more
    true digital) switching.
2017-09-06 ST Bluetooth library works, but not with cubemx yet
2017-09-07 Input Voltage Regulator
    With overvoltage protection and revece voltage protection features.
2017-09-07 Please keep it clean
    Power supply to it's own folder...
2017-09-08 Presentationsmappar
    Lägg till en fil med ditt namn, eller en mapp med ditt namn innehållande
    presentationsmaterial för ditt arbete. Försök följa formatet Namn_Ämne,
    exempel:
    DANIEL_GPS (.txt, .pdf, .tex, .fig, mapp, osv)
2017-09-08 App feedback och bluetooth
2017-09-08 Added IMU Circuit schematic to Hardware
2017-09-08 Libs and done first sketch GPS
    Added depleted MOSFET library
    Completed GPS wiring
2017-09-11 Presentation 2
2017-09-12 BT SPI busy problem
2017-09-12 Bluetooth lib should work with cubeMX now
2017-09-12 Removed unused code, fixed warnings
2017-09-13 More bluetooth app stuff
2017-09-13 Cleaning app
2017-09-13 Added various docs
2017-09-14 Bluetooth connection
2017-09-14 Added bluetooth datasheet
2017-09-14 INA126
    Force sensor schematic
2017-09-14 INA126
    bla
2017-09-14 Shematic merger and stuff
2017-09-15 More app cleaning
2017-09-16 stuff
2017-09-16 spblt-rf datasheet
2017-09-16 Added Bluetooth datasheet to list
2017-09-17 Acc/gyro LSM6DSL read orientation
2017-09-17 Started writing report about software
2017-09-17 Added BT Schematic to Hardware
2017-09-18 Shitload of hardware stuff
    * Added libraries
    * Added footprints
    * Moved stuff and updated local libraries (Hardware ->
    schematic_modules)
    * Drawn some footprints (LGA-14)
    * Edited library (BT had two 5 pin)
2017-09-18 Rename kf.txt to kf.tex
2017-09-18 report
2017-09-19 Refactored firmware main.c
2017-09-19 Added MadgwickAHRS for IMU code
2017-09-19 IMU works with Processing orientation app
2017-09-19 BT sends real sensor data for temp,press,hum, etc
2017-09-20 PCB v0.1.0
    * Changed components to SMD
    * Added Measurement nodes for all datalines
    * Designed PCB (Rather big now, only a first edition!)
    * "Fixed" fucked up power flags
2017-09-20 Small PCB update and Manufacturing
    * CPU_Board v0.1.1
    * Manufacturing files (Gerbers, mapping, drill etc.)
2017-09-20 Madgwick now works with magnometer
2017-09-20 Refactored code for readability, add ADC gen code
2017-09-20 Simple mag calibration
2017-09-21 Read ADC (load cell pin)
2017-09-21 Send correct euler angles over BT
2017-09-21 Update code from cube
2017-09-21 Improved UART handling, print GPS output to terminal
2017-09-22 Ready to manufacture!
2017-09-22 PCB_Design v0.2
    Added, changed and stuff.
    Libraries and stuff.
    Looks like shit, but it should work.
    Will check later and then send gerbers.
2017-09-22 Added zipped folder to Jan
    (CPU_PCB at v0.1.1)
2017-09-22 Work on the report
    Work on the report, fixed a folder for figures
2017-09-24 App show acc graphically on on feedback
2017-09-24 Read GPS (NMEA) by UART. Add basic user cmd shell.
2017-09-24 Filled out report introduction
2017-09-24 presentation stuff
2017-09-25 ekf updatering
2017-09-25 Android del
2017-09-25 Demo version
2017-09-25 Refactor firmware code
2017-09-25 More firmware code refactoring
2017-09-26 More gatt services
2017-09-26 Fix .tex file encoding problem, correct figure file names
2017-09-27 Add Bluetooth GPS service
2017-09-28 Refactored firmware code
2017-09-28 Added range sensor stuff
2017-09-28 read multiple bt char
2017-09-28 Fix problem when sending floats over Bluetooth
2017-09-29 Add Eclipse formatter code style
2017-09-29 Better bt/usb output rate setting
2017-09-29 Report, sensors
2017-09-29 Put in correct gps pos when opening map view
2017-09-30 Environment sensors BT send receive works now
2017-09-30 Android app draws travel route to map once per sec
2017-10-01 Better env sensor formatting in app
2017-10-01 Byte->float array conversion method
2017-10-01 Improve UART FIFO handling. Fix issue with timer reset for UART.
2017-10-02 Added next rev PCB todo list
2017-10-02 Added IMU board datasheet
2017-10-02 size of PCB
2017-10-03 Add simple MATLAB serial plotting script
2017-10-03 More robust MATLAB serial read
2017-10-03 Changed to gl object. Added drift and compass for feedback.
2017-10-03 Improve MATLAB serial read (binary mode)
2017-10-03 Improve MATLAB serial read some more
2017-10-04 Create log file and history view
2017-10-04 Write random to log and read log
2017-10-04 Firmware optimize for size needed
2017-10-05 Faster sensor logging in MATLAB
2017-10-05 More crashfix
2017-10-05 Minor firmware code cleaning
2017-10-06 MATLAB script stores datetime and delta time
2017-10-07 Graphs
2017-10-08 Added rev. 2 Schematic and netlist
    * nRST st to PC0
    * GPS nRST set to PC1
    * Load cell 1 set to PC4
    * Added Load cell 2 set to PC5
    * LPS22HB DRDY set to PB10
    * LPS22HB SA0 set to PB13
2017-10-10 Log real sensor values
2017-10-10 Update NMEA library
2017-10-10 Fix GPS position format in new NMEA lib
2017-10-10 Fix MATLAB script issue
2017-10-12 Log and BT as service implemented
2017-10-12 Improve MATLAB script usability
2017-10-13 Refactored code in MATLAB script
2017-10-13 Simple range sensor polling works
2017-10-13 Lite presentationsbilder
2017-10-14 Improve range sensor code, add range module SHDN pin
2017-10-16 Added drift calculations, not tested with board.
2017-10-17 Send GPS speed and direction over BT
2017-10-17 BT sends range sensor value in cm
2017-10-18 Added range, speed and bearing to bt
2017-10-19 Fix project path warning, increase range sensor init delay
2017-10-19 Report more about firmware. Moved figures.
2017-10-19 Revert accidental changes
2017-10-20 Report on madgwick
2017-10-21 Update report about firmware
2017-10-21 Improve range measure code, increase MATLAB serial rate
2017-10-22 Wrote on report
2017-10-25 txt2speech osv
2017-10-26 Try to restart stalling I2C bus
2017-10-29 PCB Rev 2 on the way
    /Somewhat/ done with the layout
2017-10-30 Android
2017-10-30 images.....
2017-10-30 Update HAL library
2017-11-01 Fix I2C reset issue
2017-11-01 Gasgauge schematic
    Gasgauge schematic with buck converter and soft latch power switch
2017-11-02 compiled main in report
2017-11-04 Chackpoint PCB rev2
    * Added datasheets for LSM9DS1 and STEVAL board
    * Drawn footprints for:
    o Connectors (JST)
    o LGA-12_2x2mm "Handsolder friendlier"
    o LGA-24L_3x3.5 "Handsolder friendlier"
    * Drawn symbol for LSM9DS1
2017-11-06 PCB rev2.0 complete-ish
    Rev 2 completed, except for LSM9DS1 ports: "SDO-A/G", "SDO-M" and "Data
    enable A/G"
2017-11-06 Silkscreen annotations
    Good-ish looking silkscreen~~
2017-11-07 PCB rev2 complete
2017-11-07 Battery management
    Gasgauge schematic and pcb layout
2017-11-09 Complete PCB rev2.1
    Completed, rendered gerbers, rendered drill and order sent to Jan
    refering to myself as his dear friend.
2017-11-11 Presentation 10
2017-11-11 Waves!
2017-11-13 Oskars update
2017-11-13 SKRIV
2017-11-14 mer skriva
2017-11-14 More physics
2017-11-14 goals
2017-11-16 More view
2017-11-17 Stuff for rev 3...
2017-11-18 Small stuff
2017-11-18 Some sensors comments and edits
2017-11-18 Added hw_design.tex
    It's literally empty though..
2017-11-21 Create Kalman_Filter
2017-11-21 Create hej
2017-11-21 Create tja
2017-11-21 Create data
2017-11-21 Create ta
2017-11-24 Fixes
    Some fixes (now implemented to the PCB)
2017-11-24 Added CPU Board rev3
2017-11-25 Rev 2 last ed. Rev 3 "merge"
2017-11-25 Schematic merge and pcb layout fixes
    All minor bugs now fixed, Next up is Footprint and library errors,
    followed by actual improvements.
2017-11-27 Presenattion
2017-11-27 IMU footprints more solderable
2017-11-29 Adjusted for pcb rev2
2017-11-30 Pressure
2017-12-03 Fix Android pressure and battery reading from BT
2017-12-03 FW: Add battery and pressure BT service
2017-12-03 Fix GPS problem
2017-12-03 Fix board rev 2 imu axis directions
2017-12-03 Default build to dev boards
2017-12-04 Rev 3 (most stuff)
2017-12-04 Rev 3 most done commit log
    * Fixed all footprints to HS
    * Updated and reallocated netlist
    * Updated schematics
    * Added rst button
    * worked on PCB layout
2017-12-04 Added battery chip ref manual
2017-12-04 Presentation
2017-12-04 Create C_code_INS_KF
2017-12-04 Create tet
2017-12-05 Fixed layouts for different screens
2017-12-05 Rapport
2017-12-05 Stable release bugfree version...
2017-12-06 Revision 3 routed and completed
    * Schematic completed
    * Layout of components complete
    * Routing complete
    * Excessive via placing complete (All potential antennas, no matter how
    slight should have been prevented)
    * Gerbers generated
2017-12-06 last fixes
2017-12-06 last fixes
    * Changed footprints for OPAMPS
    * Rerouted GPS_Vout
    * New gerbers
2017-12-06 Oskar is on a roll
2017-12-06 Final build
2017-12-06 More app
2017-12-07 Software
2017-12-07 CAD-filer
2017-12-07 Fix permission bug, improve layout
2017-12-07 Fix map issue
2017-12-07 Software results
2017-12-08 Oskar
2017-12-08 compiled report
2017-12-08 Laga mer
2017-12-12 Wrote report
2017-12-13 More report writing
2017-12-15 Report stuff
2018-01-06 Fixa tempus
2018-01-09 Added appendix to report, fixed last error in pcb layout (missing junction)
2018-01-09 whoops, last commit was uncomplete
2018-01-09 Firmware works on PCB rev3
2018-01-09 Add abbrev. glossary to report
2018-01-09 Remove extra dots in glossary
2018-01-09 Some HW report done..
2018-01-10 APK for easy install
2018-01-10 Sensors on the report
2018-01-10 Attributed introduction to Kenny
2018-01-11 report and schematics
2018-01-11 Broadcast battery as new gatt service
2018-01-11 images, some more report and weird glossary problem.
2018-01-11 Last version?
2018-01-11 More reporting
2018-01-11 Order of Chapters revised, Authors of chapters revised
2018-01-11 Report, sensors and reference
2018-01-11 Report stuff again
2018-01-12 App again
2018-01-12 Fixing most issues with Elias chapter
2018-01-13 bms report images
2018-01-13 figure referencing
2018-01-13 bms citing
2018-01-13 well this will need a merge
2018-01-13 BMS KiCad
2018-01-13 Frontpage update
2018-01-13 some edits
2018-01-13 small edits
2018-01-13 Correct Josef Casing section
2018-01-13 Minor grammar fix
2018-01-13 Kikat igenom BMS delen
2018-01-13 glossary uppdate
2018-01-13 references update
2018-01-14 appendix fix
2018-01-14 Some editing
2018-01-14 I have no clue what this is.
2018-01-14 Compressing Figures (Fixing problem with Report size)
2018-01-14 Fixed BMS appendix, arranged figures in android.tex
2018-01-14 Small edits here and there
2018-01-14 Added the revised sensor.tex
2018-01-14 Introduction edit, last push
2018-01-15 All chapters edited to follow the same standard. Some further compressing of images has been done as well.
2018-01-15 Added citations and glossary entries
2018-01-15 Added BOM to appendix
2018-01-15 Fixes
2018-01-15 emph
2018-01-16 references...
2018-01-16 Just up to date commit
2018-01-16 $~\textrm{}$
2018-01-16 Added to hw discussion
2018-01-16 I suppose Kenny is right...
2018-01-16 done for now.
2018-01-16 Done
2018-02-17 Fix glossaries linking
2018-02-17 Fix sw chapter images
2018-02-18 Fix some glossary entries
2018-02-18 Compressed figures
2018-02-18 Updating captions and compressing some figures
2018-02-19 Captionsource updates
2018-02-20 Added captionsource to casing.tex
2018-02-20 Fixade länkarna till bilderna.
2018-02-20 Fix captionsource problems
2018-02-22 image referencing
2018-02-22 Fix report figure file exts
