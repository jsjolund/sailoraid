# Repository jsjolund/sailoraid (continued)

## KiCad design Hardware/CPU_Board_rev2/CPU_Board.kicad_pcb

Parts:
C1: 1u; C_0805_HandSoldering
C2, C3: 18p; C_0805_HandSoldering
C4, C5, C10, C30: 4.7u; CP_Elec_3x5.3
C6, C8, C9, C11, C12, C13, C14, C15, C17, C18, C20, C23, C24, C27, C32, C33, C34, C36, C37, C39: 100n; C_0805_HandSoldering
C7, C16, C19: 10u; CP_Elec_5x5.3
C21: 2.2u; C_0805_HandSoldering
C22: 1uF; C_0805_HandSoldering
C25: 220nF; C_0805_HandSoldering
C26, C35: 10uF; CP_Elec_5x5.3
C28, C29, C31: 100nF; C_0805_HandSoldering
C38: 10n; C_0805_HandSoldering
D1: D_Zener; D_SOD-323
D2: D_Photo; PhotoDiode_SFH205
IM1: LSM9DS1; LGA-24L_3x3.5mm_Pitch0.43mm_Handsolder
JP1, JP2, JP5, JP6, JP7: Jumper_NC_Small; Pin_Header_Straight_1x02_Pitch2.54mm
JP3, JP4: Jumper_NC_Dual; Pin_Header_Straight_1x03_Pitch2.54mm
L1: L_Core_Ferrite_500mA; R_1206_HandSoldering
L2, L3: 330uH; INDUCTOR_V
P1: CONN_01X02; AK300-2
P2: USB_B; USB_Micro-B
P3, P4: CONN_01X04; Connector_JST_S4B-ZR_1x4
P5, P11: CONN_01X06; Pin_Header_Straight_1x06_Pitch2.54mm
P6: CONN_02X12; DIP-24_W15.24mm_Socket
P7, P8, P9, P10: CONN_01X02; Pin_Header_Straight_1x02_Pitch2.54mm
P12, P14, P18: CONN_01X03; Pin_Header_Straight_1x03_Pitch2.54mm
P13, P15, P16, P17: CONN_01X01; Pin_Header_Straight_1x01_Pitch2.54mm
P19, P20, P22, P23: CONN_01X01; MountingHole_2.2mm_M2_DIN965_NoPad
P21: CONN_01X06; Socket_Strip_Straight_1x06
P24: CONN_01X06; JST_PH_S6B-PH-K_06x2.50mm_Angled
P25, P26: CONN_01X04; Pin_Header_Straight_1x04_Pitch2.54mm
Q1: Q_PMOS_GSD; SOT-23_Handsoldering
Q2, Q3: Q_PNP_BCE; SOT-23_Handsoldering
R1, R2, R7, R11, R12, R16, R17, R18, R19: 10k; R_0805_HandSoldering
R3: 2.7k; R_0805_HandSoldering
R4, R5: 6.8k; R_0805_HandSoldering
R6, R8: 10K; R_0805_HandSoldering
R9: 47K; R_0805_HandSoldering
R10, R13: 5k; R_0805_HandSoldering
R14: 220; R_0805_HandSoldering
R15: 1k; R_0805_HandSoldering
R21: 0R; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
RV1, RV2: 360; Potentiometer_Trimmer_Bourns_PV36W
U1: STM32F411RETx; LQFP-64_10x10mm_Pitch0.5mm
U2: NCP1117DT12G; SOT-223
U3: FT232RL; SSOP-28_5.3x10.2mm_Pitch0.65mm
U4: HTS221; HLGA-6L_2x2x.9mm
U5, U12: INA128; SO-8_5.3x6.2mm_Pitch1.27mm
U6: SPBTLE-RF; ST_SPBTLE
U7: A2235-H; A2235-H_Handsolder
U8: LSM303AGR; LGA-12_2x2mm_Pitch0.5mm_Handsolder
U9: LSM6DSL; LGA-14
U10: MCDTS2-4N; SW_SPST_PTS645
U11: LPS22HB; HLGA-10L
Y1: 8MHz; Crystal_SMD_HC49-SD

Connections:
+3.3VADC: C18.1, L3.1, P18.3
+3V3: C1.2, C4.1, C10.1, C11.2, C13.2, C15.2, C17.2, C19.1, C20.1, C22.1, C24.1, C33.2, JP1.1, JP2.1, JP4.2, JP5.1, JP6.1, JP7.1, L3.2, P5.1, P12.3, P21.6, P24.6, R1.2, R6.2, R8.2, R11.1, R12.1, R17.1, R18.2, R19.1, U1.1 (VBAT), U1.13 (VREF+), U1.19 (VDD), U1.32 (VDD), U1.48 (VDD), U1.64 (VDD), U3.4 (VCCIO), U6.5 (VIN), U7.3 (VCC_3V3)
+5V: C9.1, C12.1, C16.1, JP3.2, L2.2, P12.1, R14.1, U2.3 (VI)
+5VA: C14.1, L2.1, P3.4, P4.4, P18.1, P25.4, P26.4, U5.7 (V+), U12.7 (V+)
/303C_I_XL: P14.2, U1.20 (ADC1_IN4/I2S1_WS/I2S3_WS/SPI1_NSS/SPI3_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), U8.12 (INT_XL)
/BT_CL: P11.5, R6.1, U1.15 (ADC1_IN1/I2S4_SD/SPI4_MOSI/TIM2_CH2/TIM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), U6.10 (SPI_CS)
/BT_CS: P11.2, U1.55 (I2C2_SDA/I2S1_CK/I2S3_CK/SPI1_SCK/SPI3_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), U6.7 (SPI_CLK)
/BT_IRQ: P11.6, R9.2, U6.4 (SPI_IRQ)
/BT_MISO: P11.3, U1.22 (ADC1_IN6/I2S2_MCK/SDIO_CMD/SPI1_MISO/TI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), U6.8 (SPI_MISO)
/BT_MOSI: P11.4, U1.23 (ADC1_IN7/I2S1_SD/SPI1_MOSI/TIM1_CH1N/TI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), U6.9 (SPI_MOSI)
/BT_RST: P11.1, R8.1, U1.41 (I2C3_SCL/RCC_MCO_1/SDIO_D1/TIM1_CH1/USA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), U6.11 (~BT_RESET~)
/DRDY_Mag: IM1.9 (DRDY_M), P6.16, P14.3, U1.26 (ADC1_IN8/I2S5_CK/SPI5_SCK/TIM1_CH2N/TIM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), U8.11 (DRDY_MAG)
/GPS_NRST: U1.9 (PC1/ADC1_IN11), U7.1 (nRST)
/GPS_RX: P8.1, R12.2, U1.42 (I2C3_SMBA/SDIO_D2/TIM1_CH2/USART1_TX/US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), U7.22 (RX0)
/GPS_TOGGLE: P13.1, R16.2, U1.44 (ADC1_EXTI11/SPI4_MISO/TIM1_CH4/USART1_C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), U7.19 (ON_OFF)
/GPS_TX: P8.2, R11.2, U1.43 (I2S5_SD/SPI5_MOSI/TIM1_CH3/USART1_RX/US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), U7.21 (TX0)
/HTS_DRDY: P15.1, U1.36 (ADC1_EXTI15/I2S2_SD/RTC_REFIN/SDIO_CK/S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), U4.3 (DRDY)
/HTS_VDD: C21.1, C23.1, JP1.2, U4.1 (VDD), U4.6 (CS)
/IMU_I2C_CL: IM1.2 (SCL/SPI), P6.20, P21.2, P24.2, R17.2, U1.61 (I2C1_SCL/I2C3_SDA/I2S5_SD/SDIO_D4/SPI5_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), U4.2 (SCL/SPC), U8.1 (SCL), U9.13 (SCL), U11.2 (SCL/SPC)
/IMU_I2C_DA: IM1.4 (SDA/SDI/SDO), P6.21, P21.1, P24.1, R19.2, U1.62 (I2C1_SDA/I2C2_SDA/I2S2_WS/SDIO_D5/SPI2_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), U4.4 (SDA/SDI/SDO), U8.4 (SDA/SDI/SDO), U9.14 (SDA), U11.4 (SDA/SDI/SDO)
/INT_Mag: IM1.10 (INT_M), P6.17, P14.1, U1.21 (ADC1_IN5/I2S1_CK/SPI1_SCK/TIM2_CH1/TIM2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), U8.7 (INT_MAG)
/LPS_DRDY: P10.1, U1.29 (I2C2_SCL/I2S2_CK/I2S3_MCK/SDIO_D7/SPI2_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), U11.7 (INT_DRDY)
/LPS_SA0: P10.2, U1.34 (I2S2_CK/I2S4_CK/SPI2_SCK/SPI4_SCK/TIM1_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), U11.5 (SDO/SA0)
/LPS_VDD: C30.1, C32.1, JP2.2, U11.1 (VDD_IO), U11.6 (CS), U11.10 (VDD)
/LSM6DSL_INT1: IM1.11 (INT_A/G), P6.14, P9.2, U1.56 (I2C3_SDA/I2S3_ext_SD/SDIO_D0/SPI1_MISO/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), U9.4 (INT1)
/LSM6DSL_INT2: IM1.12 (INT2_A/G), P6.15, P9.1, U1.57 (I2C1_SMBA/I2S1_SD/I2S3_SD/SDIO_D3/SPI1_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), U9.9 (INT2)
/LSM6_VDD: C28.1, JP7.2, U9.1 (SA0), U9.2 (SDx), U9.3 (SCx), U9.5 (VDDIO), U9.8 (VDD), U9.12 (CS)
/LSM9_CS_A/G: C35.1, C36.1, C37.1, IM1.1 (VDDIO), IM1.3 (VDDIO), IM1.7 (CS_A/G), IM1.8 (CS_M), IM1.22 (VDD), IM1.23 (VDD), JP5.2, P6.1, P6.2, P6.18, P6.19
/LSM9_DEN_A/G: IM1.13 (DEN_A/G), P6.23
/LSM303_VDD: C26.1, C29.1, C31.1, JP6.2, U8.2 (CS_XL), U8.3 (CS_MAG), U8.9 (VDD), U8.10 (VDD_IO)
/Load_cell_amp_1: P16.1, U1.24 (PC4/ADC1_IN14), U12.6
/Load_cell_amp_2: P17.1, U1.25 (PC5/ADC1_IN15), U5.6
/NRST: P5.5, R1.1, U1.7 (NRST), U1.8 (PC0/ADC1_IN10)
/SWCLK: P5.2, U1.49 (SYS_JTCK-SWCLK/PA14)
/SWDIO: P5.4, U1.46 (SYS_JTMS-SWDIO/PA13)
/USB3V3: C34.1, JP4.3, U3.17 (3V3OUT)
/USB5V: C6.1, C7.1, C8.1, JP3.3, L1.2, U3.20 (VCC)
/USB_USART_RX: P7.2, U1.17 (ADC1_IN3/I2S2_MCK/TIM2_CH4/TIM5_CH4/TIM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), U3.1 (TXD)
/USB_USART_TX: P7.1, U1.16 (ADC1_IN2/I2S_CKIN/TIM2_CH3/TIM5_CH3/TIM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), U3.5 (RXD)
/U_BUT: C27.1, R18.1, U1.2 (PC13/ANTI_TAMP/RTC_AF1), U10.1
/VL_C9: P21.3, P24.3, U1.40 (PC9/I2C3_SDA/I2S_CKIN/RCC_MCO_2/SDIO_D1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)
/VL_C10: P21.4, P24.4, U1.51 (PC10/I2S3_CK/SDIO_D2/SPI3_SCK)
GNDA: C14.2, C18.2, P3.1, P4.1, P18.2, P25.1, P26.1, R21.2, U5.4 (V-), U5.5 (Ref), U12.4 (V-), U12.5 (Ref)
unnamed: C2.1, U1.5 (PH0/RCC_OSC_IN), Y1.1
unnamed: C3.1, U1.6 (PH1/RCC_OSC_OUT), Y1.2
unnamed: C5.1, U1.30 (VCAP1)
unnamed: C25.1, U8.5 (C1)
unnamed: C38.1, IM1.21 (CAP)
unnamed: C39.1, IM1.24 (C1)
unnamed: D1.1 (K), R3.2, R4.2
unnamed: D2.1 (K), R14.2
unnamed: JP3.1, Q3.2 (C)
unnamed: JP4.1, U2.2 (VO), U2.4 (VO)
unnamed: L1.1, P2.1 (VBUS)
unnamed: P1.2, Q1.3 (D)
unnamed: P2.2 (D-), U3.16 (USBDM)
unnamed: P2.3 (D+), U3.15 (USBDP)
unnamed: P3.2, P25.2, U5.2 (-)
unnamed: P3.3, P25.3, U5.3 (+)
unnamed: P4.2, P26.2, U12.2 (-)
unnamed: P4.3, P26.3, U12.3 (+)
unnamed: Q1.2 (S), Q2.3 (E), Q3.3 (E), R3.1
unnamed: Q2.1 (B), R4.1
unnamed: Q2.2 (C), Q3.1 (B), R5.2
unnamed: R2.1, U1.60 (BOOT0)
unnamed: R7.1, U7.5 (Vout)
unnamed: R7.2, U7.7 (GPIO6/SPI_CLK)
unnamed: R10.1, RV1.1, RV1.2, U5.1 (Rg)
unnamed: R10.2, RV1.3, U5.8 (Rg)
unnamed: R13.1, RV2.3, U12.1 (Rg)
unnamed: R13.2, RV2.1, RV2.2, U12.8 (Rg)
unnamed: R15.2, U10.2

Notes on the sheet:
NOTE: RX to TX, TX to RX
Mounting Holes
USB USART Connection for Programming Using FT232RL
Measurement Nodes MCU
Main chip, STM32F411RET, and lables only. Sensor architectures in their own boxes, well documented.
Required circuitry
Autowakeup: 4 to 16
Antenna? To where?
7op for I2C , 7cl for UART;
8op for UART, 8cl for I2C;
Timekeeping? 1PPS signal
For I2C use
GPS: A2235-H schematic Datasheet: http://www.mouser.com/catalog/specsheets/EVA2235-H.pdf
Pullups
GPS
Amplifier for load cell, connects to JST-TH and Analog
LSM303AGR VDD Decoup. Cap.
LSM303AGR VDD_IO Decoup. Cap.
LSM6DSL VDD Decoup. Cap.
IMU circuitry
Bluetooth connection module
Power input from battery dock board
Measurement Nodes USB
Measurement Nodes GPS
Toggle signal GPS
1: Magneto & Acc. 2: Gyro & Acc. 3: Humidity 4. Pressure
IMU 1 pins
IMU 2 interrupt pins
Reset SPI_MISO SPI_CLK SPI_MOSI SPI_CS SPI_IRQ
Measurement Nodes BT-LE
Measurement Nodes Digital Power Pins
Measurement Nodes Analog Power Pins
Measurement Nodes Load Cell 1
Meta circuitry (Measurement nodes & Mounting)
Modules
Power Flags
GP Button.
Micro_USB-B
IMU_1
IMU_2

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
Board: 2 copper layers, 100.0 x 70.0 mm, 116 parts (0 on the bottom side), 74 nets.

## KiCad design Hardware/Gasgauge/bq28z610/2sBatteryCharger.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C8, C9: 0.1uF; C_0805_HandSoldering
C7: 2.2uF; C_0805_HandSoldering
C10: 1uF; C_0805_HandSoldering
C11: 680uF; CP_Elec_8x10
C12: 47uF; CP_Elec_6.3x5.3
C13: 220uF; CP_Elec_6.3x5.8
D1, D2, D3: D_Schottky; D_0805
F1: Fuse; Fuseholder5x20_horiz_open_lateral_Type-II
J1: PACK; JST_XH_S02B-XH-A_02x2.50mm_Angled
J2: SCL/SDA; JST_XH_S02B-XH-A_02x2.50mm_Angled
J3: BAT2; JST_XH_S02B-XH-A_02x2.50mm_Angled
J4: BAT1; JST_XH_S02B-XH-A_02x2.50mm_Angled
J5: OUTPUT; JST_XH_S02B-XH-A_02x2.50mm_Angled
L1: 33uH; L_12x12mm_h8mm
Q1, Q2: CSD16412Q5A; TDSON-8-1_HandSoldering
Q3: 2N7002; SOT-23
Q4: Q_PMOS_GSD; SOT-23
Q5, Q6: 2N3904; TSOT-23
R1, R2, R3, R5, R6, R7, R12: 100; R_0805_HandSoldering
R4: 1-3m; R_2512
R8: 10k; R_0805_HandSoldering
R9, R14: 10M; R_0805_HandSoldering
R10: 10; R_0805_HandSoldering
R11, R15: 5.1k; R_0805_HandSoldering
R13: 5; R_0805_HandSoldering
R16, R17, R19: 100k; R_0805_HandSoldering
R18: 1M; R_0805_HandSoldering
SW1: SW_Push; WireConnection_0.80mmDrill
TH1: Thermistor_NTC; JST_XH_S02B-XH-A_02x2.50mm_Angled
U1: bq28z610; Texas_S-PDSO-N12
U2: LM2596; TO-263-5_TabPin3

Connections:
/INlatch: C13.1, L1.2, Q4.2 (S), R16.1, R19.1, U2.4 (Feedback)
/OUTlatch: J5.2, Q4.3 (D), R17.1, R18.1
/PACK+: C3.1, C6.2, C11.1, J1.2, Q2.1 (S), Q2.2 (S), Q2.3 (S), Q3.2 (S), R9.1, R10.2, U2.1 (IN)
/SCL: J2.2, R1.2
/SDA: J2.1, R2.2
GND: C1.2, C2.2, C7.2, C8.2, J4.1, R4.2, R5.1, TH1.2, U1.1 (VSS), U1.13 (PWPD)
GNDPWR: C4.2, C11.2, C12.2, C13.2, D1.2 (A), D2.2 (A), D3.2 (A), J1.1, J5.1, Q5.1 (E), Q6.1 (E), R3.1, R4.1, R8.2, U2.3 (GND), U2.5 (ON/OFF)
unnamed: C1.1, C5.2, R3.2, U1.2 (SRN)
unnamed: C2.1, C5.1, R5.2, U1.3 (SRP)
unnamed: C3.2, C4.1
unnamed: C6.1, C9.2
unnamed: C7.1, U1.10 (PBI)
unnamed: C9.1, F1.1, Q1.1 (S), Q1.2 (S), Q1.3 (S), R14.2
unnamed: C8.1, C10.1, R12.2, U1.12 (VC1)
unnamed: C10.2, R13.2, U1.11 (VC2)
unnamed: C12.1, Q6.2 (B), R18.2
unnamed: D1.1 (K), R1.1, R6.2
unnamed: D2.1 (K), R2.1, R7.2
unnamed: D3.1 (K), L1.1, U2.2 (OUT)
unnamed: F1.2, J3.2, R13.1
unnamed: J3.1, J4.2, R12.1
unnamed: Q1.4 (G), R14.1, R15.2
unnamed: Q1.5 (D), Q2.5 (D)
unnamed: Q2.4 (G), Q3.3 (D), R9.2, R11.2
unnamed: Q3.1 (G), R8.1
unnamed: Q4.1 (G), Q5.3 (C), R16.2
unnamed: Q5.2 (B), R17.2, SW1.1
unnamed: Q6.3 (C), R19.2, SW1.2
unnamed: R6.1, U1.5 (SCL)
unnamed: R7.1, U1.6 (SDA)
unnamed: R10.1, U1.8 (PACK)
unnamed: R11.1, U1.7 (DSG)
unnamed: R15.1, U1.9 (CHG)
unnamed: TH1.1, U1.4 (TS1)

Board: 2 copper layers, 85.0 x 66.0 mm, 52 parts (0 on the bottom side), 34 nets.
