# Repository jsjolund/sailoraid

File README.md:

# sailoraid
Sensor package for the Laser Pico sail boat

[BlueNRG (Old Bluetooth module) Datasheet](Docs/BlueNRG_Datasheet.pdf)

[SPBTLE (Bluetooth module) Datasheet](Docs/BlueNRG_Datasheet.pdf)

[EVA2235-H (GPS) Datasheet](Docs/EVA2235-H.pdf)

[LSM6DSL (Acc/Gyro) Datasheet](Docs/LSM6DSL.pdf)

[LSM303C (Acc/Mag) Datasheet](Docs/LSM303C.pdf)

[STM32F411 (MCU) Datasheet](Docs/STM32F411_Datasheet.pdf)

[STM32F411 (MCU) Reference Manual](Docs/STM32F411_Reference_Manual.pdf)

## KiCad design Hardware/Gasgauge/2sBatteryCharger.kicad_pcb

Parts:
J1: Battery; JST_XH_S04B-XH-A_04x2.50mm_Angled
J2: ACadapter; JST_XH_S02B-XH-A_02x2.50mm_Angled
J3: Power; JST_XH_S02B-XH-A_02x2.50mm_Angled
P1, P2, P3, P4: CONN_01X01; MountingHole_3.2mm_M3

Connections:
/bq28z610/1P: J1.2, J1.3; also elsewhere on the board
/bq28z610/2P: J1.4; also elsewhere on the board
/bq24133/ADAPTER: J2.1; also elsewhere on the board
/lm2529/5V: J3.1; also elsewhere on the board
Earth: J2.2; also elsewhere on the board
GND: J1.1; also elsewhere on the board
GNDPWR: J3.2, P1.1, P2.1, P3.1, P4.1; also elsewhere on the board

Parts:
C1: 1u; C_0805
C2, C3, C5, C7, C12: 100n; C_0603
C4: 10u; C_1206
C6, C11: 1u; C_0603
C8, C9: 10u; C_1210
C10: 47n; C_0603
Cin1: 2.2u; C_1206
D1: D1; D_SOD-323F
D2: D2; D_SOD-323F
D3: LED; LED_D3.0mm
L1: 3.3u; L_7.3x7.3_H3.5
Q1, Q2: CSD16412Q5A; TDSON-8-1
Q3: PMOS; SOT-23
R1: 10; R_1206
R2: 5.23k; R_0603
R3: 30.1k; R_0603
R4, R6: 4.02k; R_0603
R5: 1.5k; R_0603
R7: 232k; R_0603
R8, R13: 32.4k; R_0603
R9: 1k; R_0603
R10, R11, R12, R15: 100k; R_0603
R14: 1M; R_0603
R16: 0; R_0603
RT1: 103AT; R_Axial_DIN0309_L9.0mm_D3.2mm_P2.54mm_Vertical
Rac1: 20m; R_2512
Rin1: 2; R_2010
Rsr1: 10m; R_2512
U1: bq24133; VQFN-24_5.5x3.5mm_Pitch0.5mm

Connections:
/bq24133/0.8-1.8V: R10.2, R11.2, U1.14 (CELL)
/bq24133/ADAPTER: D2.2 (A), Q1.5 (D), R14.1, Rin1.1; also elsewhere on the board
/bq24133/AVCC: C1.1, R1.2, U1.4 (AVCC)
/bq24133/DCDC: C2.2, C3.2, C4.1, Q3.3 (S), Rac1.2, U1.2 (PVCC), U1.3 (PVCC), U1.5 (ACN); also elsewhere on the board
/bq24133/PACK+: C7.1, C8.2, C9.2, D1.2 (A), Q3.1 (D), Rsr1.1, U1.15 (SRN); also elsewhere on the board
/bq24133/VREF: C6.1, R2.1, R5.2, R7.1, U1.12 (VREF)
Earth: C1.2, C2.1, C5.1, C6.2, C12.2, R3.2, R8.2, R11.1, R13.2, R15.2, R16.1, RT1.2, U1.25 (AGND); also elsewhere on the board
GNDPWR: C4.2, C8.1, C9.1, C11.2, Cin1.2, R16.2, U1.22 (PGND), U1.23 (PGND); also elsewhere on the board
unnamed: C3.1, Q2.5 (D), Rac1.1, U1.6 (ACP)
unnamed: C5.2, U1.11 (TTC)
unnamed: C10.1, U1.21 (BTST)
unnamed: C10.2, L1.1, U1.1 (SW), U1.24 (SW)
unnamed: C11.1, U1.20 (REGN)
unnamed: C7.2, C12.1, L1.2, Rsr1.2, U1.16 (SRP)
unnamed: Cin1.1, Rin1.2
unnamed: D1.1 (K), D2.1 (K), R1.1
unnamed: D3.1 (K), U1.9 (STAT)
unnamed: D3.2 (A), R5.1
unnamed: Q1.1 (S), Q1.2 (S), Q1.3 (S), Q2.1 (S), Q2.2 (S), Q2.3 (S), R6.2
unnamed: Q1.4 (G), Q2.4 (G), R4.2
unnamed: Q3.2 (G), R9.1
unnamed: R2.2, R3.1, RT1.1, U1.10 (TS)
unnamed: R4.1, U1.8 (ACDRV)
unnamed: R6.1, U1.7 (CMSRC)
unnamed: R7.2, R8.1, U1.13 (ISET)
unnamed: R9.2, U1.19 (BATDRV)
unnamed: R10.1, R12.1
unnamed: R12.2, R13.1, U1.17 (ACSET)
unnamed: R14.2, R15.1, U1.18 (OVPSET)

Parts:
Cz1, Cz2, Cz3, Cz4, Cz5, Cz6, Cz8, Cz9: 0.1u; C_0603
Cz7: 2.2u; C_0603
Cz10: 1u; C_0805_HandSoldering
Dz1: DZ1; D_SOD-323F
Dz2: DZ2; D_SOD-323F
F1: Fuse; Fuseholder5x20_horiz_open_lateral_Type-II
J4: SCL/SDA; JST_XH_S02B-XH-A_02x2.50mm_Angled
Qz1: 2N7002; SOT-23
Qz2, Qz3: CSD16412Q5A; TDSON-8-1_HandSoldering
Rz1, Rz2, Rz3, Rz5, Rz6, Rz7: 100; R_0603
Rz4: 1-3m; R_2512
Rz8: 10k; R_0603
Rz9, Rz14: 10M; R_0603
Rz10: 10; R_0603
Rz11, Rz15: 5.1k; R_0603
Rz12: 100; R_2512
Rz13: 5; R_2512
TH1: NTC; R_Axial_DIN0309_L9.0mm_D3.2mm_P2.54mm_Vertical
U2: bq28z610; Texas_S-PDSO-N12

Connections:
/bq28z610/1P: Rz12.1; also elsewhere on the board
/bq28z610/2P: F1.2, Rz13.1; also elsewhere on the board
/bq28z610/SCL: J4.1, Rz1.2
/bq28z610/SDA: J4.2, Rz2.2
/bq24133/PACK+: Cz1.1, Cz6.2, Qz1.2 (S), Qz2.1 (S), Qz2.2 (S), Qz2.3 (S), Rz9.1, Rz10.2; also elsewhere on the board
GND: Cz4.2, Cz5.2, Cz7.2, Cz8.2, Rz4.2, Rz5.1, TH1.2, U2.1 (VSS), U2.13 (PWPD); also elsewhere on the board
GNDPWR: Cz2.2, Dz1.2 (A), Dz2.2 (A), Rz3.1, Rz4.1, Rz8.2; also elsewhere on the board
unnamed: Cz1.2, Cz2.1
unnamed: Cz3.1, Cz5.1, Rz5.2, U2.3 (SRP)
unnamed: Cz3.2, Cz4.1, Rz3.2, U2.2 (SRN)
unnamed: Cz6.1, Cz9.2
unnamed: Cz7.1, U2.10 (PBI)
unnamed: Cz9.1, F1.1, Qz3.1 (S), Qz3.2 (S), Qz3.3 (S), Rz14.2
unnamed: Cz8.1, Cz10.1, Rz12.2, U2.12 (VC1)
unnamed: Cz10.2, Rz13.2, U2.11 (VC2)
unnamed: Dz1.1 (K), Rz1.1, Rz6.2
unnamed: Dz2.1 (K), Rz2.1, Rz7.2
unnamed: Qz1.1 (G), Rz8.1
unnamed: Qz1.3 (D), Qz2.4 (G), Rz9.2, Rz11.2
unnamed: Qz2.5 (D), Qz3.5 (D)
unnamed: Qz3.4 (G), Rz14.1, Rz15.2
unnamed: Rz6.1, U2.5 (SCL)
unnamed: Rz7.1, U2.6 (SDA)
unnamed: Rz10.1, U2.8 (PACK)
unnamed: Rz11.1, U2.7 (DSG)
unnamed: Rz15.1, U2.9 (CHG)
unnamed: TH1.1, U2.4 (TS1)

Parts:
Cz11: 680uF; CP_Elec_8x10
Cz12: 220uF; CP_Elec_6.3x5.8
Dz3: 1N5824; D_5W_P10.16mm_Horizontal
Lz1: 33uH; L_12x12mm_h8mm
U3: LM2596; TO-263-5_TabPin3

Connections:
/bq24133/DCDC: Cz11.1, U3.1 (IN); also elsewhere on the board
/lm2529/5V: Cz12.1, Lz1.2, U3.4 (Feedback); also elsewhere on the board
GNDPWR: Cz11.2, Cz12.2, Dz3.2 (A), U3.3 (GND), U3.5 (ON/OFF); also elsewhere on the board
unnamed: Dz3.1 (K), Lz1.1, U3.2 (OUT)

Board: 2 copper layers, 85.0 x 50.5 mm, 87 parts (0 on the bottom side), 56 nets.

## KiCad design Hardware/CPU_Board_rev3/CPU_Board.kicad_pcb

Parts:
C1: 1u; C_0805_HandSoldering
C2, C3: 18p; C_0805_HandSoldering
C4, C5, C9, C32: 4.7u; CP_Elec_3x5.3
C6, C8, C10, C11, C12, C13, C14, C15, C16, C18, C20, C21, C24, C25, C30, C31, C34, C35: 100n; C_0805_HandSoldering
C7, C17, C19: 10u; CP_Elec_5x5.3
C22: 2.2u; C_0805_HandSoldering
C23: 1uF; C_0805_HandSoldering
C26, C28, C29: 100nF; C_0805_HandSoldering
C27: 10uF; CP_Elec_5x5.3
D1: D_Zener; D_SOD-323
D2: D_Photo; PhotoDiode_SFH205
JP1, JP2: Jumper_NC_Dual; Pin_Header_Straight_1x03_Pitch2.54mm
L1: L_Core_Ferrite_500mA; R_1206_HandSoldering
L2, L3: 330uH; INDUCTOR_V
P1: CONN_01X02; AK300-2
P2: USB_B; USB_Mini-B
P3, P5: CONN_01X04; Pin_Header_Straight_1x04_Pitch2.54mm
P4, P6: CONN_01X04; Connector_JST_S4B-ZR_1x4
P7: CONN_01X06; Socket_Strip_Straight_1x06
P8: CONN_01X06; JST_PH_S6B-PH-K_06x2.54mm_Angled
P9, P14: CONN_01X06; Pin_Header_Straight_1x06_Pitch2.54mm
P10, P11, P12: CONN_01X02; Pin_Header_Straight_1x02_Pitch2.54mm
P15, P21: CONN_01X03; Pin_Header_Straight_1x03_Pitch2.54mm
P16, P19, P20: CONN_01X01; Pin_Header_Straight_1x01_Pitch2.54mm
P22, P23, P24, P25: CONN_01X01; MountingHole_2.2mm_M2_DIN965_NoPad
P26: CONN_01X04; Molex_KK-6410-04_04x2.54mm_Straight
Q1: Q_PMOS_GSD; SOT-23_Handsoldering
Q2, Q3: Q_PNP_BCE; SOT-23_Handsoldering
Q4, Q5: BSS138; SOT-23
R1, R6, R7, R9, R13, R14, R20, R21, R22: 10k; R_0805_HandSoldering
R2: 2.7k; R_0805_HandSoldering
R3, R4: 6.8k; R_0805_HandSoldering
R5: 220; R_0805_HandSoldering
R8, R10: 10K; R_0805_HandSoldering
R11: 47K; R_0805_HandSoldering
R12, R15: 5k; R_0805_HandSoldering
R16, R19: 2.2k; R_0805_HandSoldering
R17, R18: 1k; R_0805_HandSoldering
R23: 0R; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R24, R25, R26, R27: R; R_0805_HandSoldering
RV1, RV2: 360; Potentiometer_Trimmer_Bourns_PV36W
U1: STM32F411RETx; LQFP-64_10x10mm_Pitch0.5mm
U2: FT232RL; SSOP-28_5.3x10.2mm_Pitch0.65mm
U3: NCP1117DT12G; SOT-223
U4: HTS221; HLGA-6L_2x2x.9mm_HS
U5, U13: INA128; SOIC-8_3.9x4.9mm_Pitch1.27mm
U6: SPBTLE-RF; ST_SPBTLE
U7: A2235-H; A2235-H_Handsolder
U8: LSM303AGR; LGA-12_2x2mm_P.5mm_HS
U9: LSM6DSL; LGA-14_2.5x3mm_P.5_HS
U10, U11: MCDTS2-4N; SW_SPST_PTS645
U12: LPS22HB; HLGA-10L_2x2mm_P.5mm_HS
Y1: 8MHz; Crystal_SMD_HC49-SD

Connections:
+3.3VADC: C21.1, L3.1, P21.3
+3V3: C1.2, C4.1, C9.1, C11.2, C12.2, C14.2, C15.2, C19.1, C20.1, C22.1, C23.1, C24.1, C25.1, C27.1, C28.1, C29.1, C32.1, C34.1, C35.2, JP2.2, L3.2, P7.1, P8.1, P9.1, P15.3, Q4.1 (G), Q5.1 (G), R6.1, R7.1, R8.2, R10.2, R13.1, R14.1, R20.2, R21.2, R26.2, R27.2, U1.1 (VBAT), U1.13 (VREF+), U1.19 (VDD), U1.32 (VDD), U1.48 (VDD), U1.64 (VDD), U2.4 (VCCIO), U4.1 (VDD), U4.6 (CS), U6.5 (VIN), U7.3 (VCC_3V3), U8.2 (CS_XL), U8.3 (CS_MAG), U8.9 (VDD), U8.10 (VDD_IO), U9.1 (SA0), U9.2 (SDx), U9.3 (SCx), U9.5 (VDDIO), U9.8 (VDD), U9.12 (CS), U12.1 (VDD_IO), U12.6 (CS), U12.10 (VDD)
+5V: C13.1, C16.1, C17.1, JP1.2, L2.2, P15.1, R5.1, U3.3 (VI)
+5VA: C18.1, L2.1, P3.4, P4.4, P5.4, P6.4, P21.1, U5.7 (V+), U13.7 (V+)
/BT_CLK: P14.2, U1.55 (I2C2_SDA/I2S1_CK/I2S3_CK/SPI1_SCK/SPI3_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), U6.7 (SPI_CLK)
/BT_CS: P14.5, R8.1, U1.15 (ADC1_IN1/I2S4_SD/SPI4_MOSI/TIM2_CH2/TIM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), U6.10 (SPI_CS)
/BT_IRQ: P14.6, R11.2, U1.14 (ADC1_IN0/SYS_WKUP/TIM2_CH1/TIM2_ETR/TIM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), U6.4 (SPI_IRQ)
/BT_MISO: P14.3, U1.22 (ADC1_IN6/I2S2_MCK/SDIO_CMD/SPI1_MISO/TI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), U6.8 (SPI_MISO)
/BT_MOSI: P14.4, U1.23 (ADC1_IN7/I2S1_SD/SPI1_MOSI/TIM1_CH1N/TI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), U6.9 (SPI_MOSI)
/BT_RST: P14.1, R10.1, U1.41 (I2C3_SCL/RCC_MCO_1/SDIO_D1/TIM1_CH1/USA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), U6.11 (~BT_RESET~)
/GPS_NRST: U1.8 (PC0/ADC1_IN10), U7.1 (nRST)
/GPS_RX: P11.1, R14.2, U1.42 (I2C3_SMBA/SDIO_D2/TIM1_CH2/USART1_TX/US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), U7.19 (RX0)
/GPS_TOGGLE: P16.1, R22.2, U1.38 (PC7/I2S2_CK/I2S3_MCK/SDIO_D7/SPI2_SCK/T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), U7.16 (ON_OFF)
/GPS_TX: P11.2, R13.2, U1.43 (I2S5_SD/SPI5_MOSI/TIM1_CH3/USART1_RX/US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), U7.18 (TX0)
/GPS_Vout: R9.1, R16.1, R19.1, U7.5 (Vout)
/HTS_DRDY: U1.36 (ADC1_EXTI15/I2S2_SD/RTC_REFIN/SDIO_CK/S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), U4.3 (DRDY)
/IMU_I2C_CL: P7.5, P8.5, P12.2, Q4.2 (S), R6.2, R26.1, U1.61 (I2C1_SCL/I2C3_SDA/I2S5_SD/SDIO_D4/SPI5_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), U4.2 (SCL/SPC), U8.1 (SCL), U9.13 (SCL), U12.2 (SCL/SPC)
/IMU_I2C_DA: P7.6, P8.6, P12.1, Q5.2 (S), R7.2, R27.1, U1.62 (I2C1_SDA/I2C2_SDA/I2S2_WS/SDIO_D5/SPI2_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), U4.4 (SDA/SDI/SDO), U8.4 (SDA), U9.14 (SDA), U12.4 (SDA/SDI/SDO)
/INT/DRDY_Mag: U8.7 (INT_MAG/DRDY)
/LPS_I_DRDY: U1.29 (I2C2_SCL/I2S2_CK/I2S3_MCK/SDIO_D7/SPI2_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), U12.7 (INT_DRDY)
/LPS_SA0: U1.34 (I2S2_CK/I2S4_CK/SPI2_SCK/SPI4_SCK/TIM1_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), U12.5 (SDO/SA0)
/LSM6DSL_INT1: U1.56 (I2C3_SDA/I2S3_ext_SD/SDIO_D0/SPI1_MISO/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), U9.4 (INT1)
/LSM6DSL_INT2: U1.57 (I2C1_SMBA/I2S1_SD/I2S3_SD/SDIO_D3/SPI1_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), U9.9 (INT2)
/Load_cell_amp_1: P19.1, U1.24 (PC4/ADC1_IN14), U13.6
/Load_cell_amp_2: P20.1, U1.25 (PC5/ADC1_IN15), U5.6
/NRST: C31.1, P9.5, R21.1, U1.7 (NRST), U11.1
/SWCLK: P9.2, U1.49 (SYS_JTCK-SWCLK/PA14)
/SWDIO: P9.4, U1.46 (SYS_JTMS-SWDIO/PA13)
/TOF_SD: P7.4, P8.4, U1.40 (PC9/I2C3_SDA/I2S_CKIN/RCC_MCO_2/SDIO_D1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)
/USB3V3: C10.1, JP2.3, U2.17 (3V3OUT)
/USB5V: C6.1, C7.1, C8.1, JP1.3, L1.2, U2.20 (VCC)
/USB_USART_RX: P10.2, U1.17 (ADC1_IN3/I2S2_MCK/TIM2_CH4/TIM5_CH4/TIM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), U2.1 (TXD)
/USB_USART_TX: P10.1, U1.16 (ADC1_IN2/I2S_CKIN/TIM2_CH3/TIM5_CH3/TIM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), U2.5 (RXD)
/U_BUT: C30.1, R20.1, U1.2 (PC13/ANTI_TAMP/RTC_AF1), U10.1
/VBat: P26.1, R24.2, R25.2
/VL_C10: P7.3, P8.3, U1.51 (PC10/I2S3_CK/SDIO_D2/SPI3_SCK)
GND: C1.1, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.1, C12.1, C13.2, C14.1, C15.1, C16.2, C17.2, C19.2, C20.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C34.2, C35.1, D1.2 (A), D2.2 (A), P1.1, P2.4 (GND), P2.5 (shield), P7.2, P8.2, P9.3, P15.2, P26.4, Q1.1 (G), R1.2, R4.1, R11.1, R17.1, R18.1, R22.1, R23.1, U1.12 (VSSA), U1.18 (VSS), U1.31 (VSS), U1.47 (VSS), U1.63 (VSS), U2.7 (GND), U2.18 (GND), U2.21 (GND), U2.25 (AGND), U2.26 (TEST), U3.1 (GND), U4.5 (GND), U6.6 (GND), U7.6 (GND), U7.9 (GND), U7.17 (ExtInt), U7.20 (GND_PAD8), U7.21 (GND_PAD7), U7.22 (GND_PAD6), U7.23 (GND_PAD1), U7.24 (GND_PAD2), U7.25 (GND_PAD3), U7.26 (GND_PAD4), U7.27 (GND_PAD5), U8.6 (GND), U8.8 (GND), U9.6 (GND), U9.7 (GND), U12.3 (RES), U12.8 (GND)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
GNDA: C18.2, C21.2, P3.1, P4.1, P5.1, P6.1, P21.2, R23.2, U5.4 (V-), U5.5 (Ref), U13.4 (V-), U13.5 (Ref)
unnamed: C2.1, U1.5 (PH0/RCC_OSC_IN), Y1.1
unnamed: C3.1, U1.6 (PH1/RCC_OSC_OUT), Y1.2
unnamed: C5.1, U1.30 (VCAP1)
unnamed: C26.1, U8.5 (C1)
unnamed: D1.1 (K), R2.2, R3.2
unnamed: D2.1 (K), R5.2
unnamed: JP1.1, Q3.2 (C)
unnamed: JP2.1, U3.2 (VO), U3.4 (VO)
unnamed: L1.1, P2.1 (VBUS)
unnamed: P1.2, Q1.3 (D)
unnamed: P2.2 (D-), U2.16 (USBDM)
unnamed: P2.3 (D+), U2.15 (USBDP)
unnamed: P3.2, P4.2, U5.2 (-)
unnamed: P3.3, P4.3, U5.3 (+)
unnamed: P5.2, P6.2, U13.2 (-)
unnamed: P5.3, P6.3, U13.3 (+)
unnamed: P26.2, Q5.3 (D), R25.1
unnamed: P26.3, Q4.3 (D), R24.1
unnamed: Q1.2 (S), Q2.3 (E), Q3.3 (E), R2.1
unnamed: Q2.1 (B), R3.1
unnamed: Q2.2 (C), Q3.1 (B), R4.2
unnamed: R1.1, U1.60 (BOOT0)
unnamed: R9.2, U7.7 (GPIO6/SPI_CLK)
unnamed: R12.1, U5.1 (Rg)
unnamed: R12.2, RV1.1, RV1.2
unnamed: R15.1, U13.8 (Rg)
unnamed: R15.2, RV2.2, RV2.3
unnamed: R16.2, U7.14 (I2C_CLK)
unnamed: R17.2, U10.2
unnamed: R18.2, U11.2
unnamed: R19.2, U7.15 (I2C_DIO)
unnamed: RV1.3, U5.8 (Rg)
unnamed: RV2.1, U13.1 (Rg)

Notes on the sheet:
NOTE: RX to TX, TX to RX
Mounting Holes
USB USART Connection for Programming Using FT232RL
Measurement Nodes MCU
Main chip, STM32F411RET, and lables only. Sensor architectures in their own boxes, well documented.
Required circuitry
Autowakeup: 4 to 16
7op for I2C , 7cl for UART;
8op for UART, 8cl for I2C;
For I2C use
GPS: A2235-H schematic Datasheet: http://www.mouser.com/catalog/specsheets/EVA2235-H.pdf
Pullups
Amplifier for load cell, connects to JST-TH and Analog
LSM303AGR VDD Decoup. Cap.
LSM6DSL VDD Decoup. Cap.
I2C circuitry
Bluetooth connection module
Power input from battery dock board
Measurement Nodes USB
Measurement Nodes GPS
Toggle signal GPS
1: Magneto & Acc. 2: Gyro & Acc. 3: Humidity 4. Pressure
I2C 2
Reset SPI_CLK SPI_MISO SPI_MOSI SPI_CS SPI_IRQ
Measurement Nodes BT-LE
Measurement Nodes Digital Power Pins
Measurement Nodes Analog Power Pins
Measurement Nodes Load Cell 1
Meta circuitry (Measurement nodes & Mounting)
Modules
Power Flags
GP Button.
Micro_USB-B
IMU_1
IMU_2
Measurement Nodes Load Cell 2
Power save if not used
Acc. & Gyro.
Acc. & Mag.
I2C 4

Board: 2 copper layers, 99.7 x 70.0 mm, 112 parts (0 on the bottom side), 70 nets.
